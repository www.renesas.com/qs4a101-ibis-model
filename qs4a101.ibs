| I/O Buffer Information Specification (IBIS) Version 3.2 (August 20, 1999)
| IBIS is a standard for electronic behavioral specifications of integrated
| circuit input/output analog characteristics.
[IBIS Ver]   3.2
[File Name]   qs4a101.ibs
[File Rev]   2.0
[Date]   October 27, 1999
[Notes]   IDT provides IBIS models as a service to our customers. You
   and your company shall not distribute, convey, sell or give
   these models to anyone else without receiving prior written
   permission from IDT. IDT reserves the right to make changes to
   its products or to discontinue any semiconductor product or
   service without notice, and advises its customers to obtain
   the latest version of relevant information to verify, before
   placing orders, that the information being relied on is
   current. Please be aware that your receipt and subsequent use
   of the IBIS information provided shall serve as acceptance of
   the terms and conditions of this agreement. If you do not
   accept these terms, you should return the IBIS model and any
   other accompanying information immediately.
[Disclaimer]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
[Copyright]   (C) Copyright 1999 Integrated Device Technology, Inc. All
   rights reserved. Unauthorized reproduction and/or distribution
   is strictly prohibited.
|   Component QS4A101
[Component]   QS4A101
[Manufacturer]   Integrated Device Technology, Inc.
[Package]
| Package parasitics.  Uncomment one set.
| variable   typ   min   max
| QSOP
R_pkg   0.01   0.01   0.01
L_pkg   2.50nH   2.50nH   2.50nH
C_pkg   0.40pF   0.40pF   0.40pF
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
|1   NC   NC   NA   NA   NA
|2   NE1   ENABLE   NA   NA   NA
3   A1   NC   NA   NA   NA
4   B1   NC   NA   NA   NA
|5   NE2   ENABLE   NA   NA   NA
6   A2   NC   NA   NA   NA
7   B2   NC   NA   NA   NA
8   GND   GND   NA   NA   NA
|9   NC   NC   NA   NA   NA
10   B3   NC   NA   NA   NA
11   A3   NC   NA   NA   NA
|12   NE3   ENABLE   NA   NA   NA
13   B4   NC   NA   NA   NA
14   A4   NC   NA   NA   NA
|15   NE4   ENABLE   NA   NA   NA
16   VCC   POWER   NA   NA   NA
[Series Pin Mapping]   pin_2   model_name   function_table_group
3   4   QSIO   1
6   7   QSIO   2
11   10   QSIO   3
14   13   QSIO   4
|   Series_MOSFET   This model type is for series switch
|   devices that can described by [On], [Off],
|   [R Series], [L Series], [Rl Series],
|   [C Series], [Lc Series], [Rc Series],
|   [Series Current] and [Series MOSFET]
|   keywords
[Model]   QSIO
Model_type   Series_switch
| variable   typ   min   max
| Silicon die-compacitance (excluding package cap)
C_comp   4.53pF   3.64pF   4.89pF
[Temperature Range]   25.0   85   -40
[Voltage Range]   5.0V   4.75V   5.25V
[On]
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[Off]
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| Models and submodels in the file (1): QSIO (Series_switch)
